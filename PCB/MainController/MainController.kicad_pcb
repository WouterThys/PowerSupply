# Repository WouterThys/PowerSupply (continued)

## KiCad design PCB/ConstantSupply/ConstantSupply.kicad_pcb

Parts:
C1, C3, C6, C7, C15, C17, C18, C19, C20, C21: 10n; C_0603_HandSoldering
C2, C14: 1µ; C_0603_HandSoldering
C4, C8, C10, C11, C16, C23, C24: 10µ; CP_Tantalum_Case-A_EIA-3216-18_Reflow
C5, C13: 2.2µ; CP_Tantalum_Case-A_EIA-3216-18_Reflow
C9, C12, C22, C25: 100n; C_0603_HandSoldering
D1, D3: D_Zener; D_5W_P10.16mm_Horizontal
D2: LED; LED_0603_HandSoldering
J1, J4: Conn_01x04; Molex_PicoBlade_53047-0410_04x1.25mm_Straight
J2, J9: 5V_Out; BARREL_JACK
J3: 5V_CLED; Pin_Header_Straight_1x02_Pitch2.54mm
J5: LCD; Molex_PicoBlade_53047-0610_06x1.25mm_Straight
J6: BTN; Molex_PicoBlade_53047-0510_05x1.25mm_Straight
J7: DV_IN; Molex_PicoBlade_53047-0410_04x1.25mm_Straight
J8: LEDs; Molex_PicoBlade_53047-0410_04x1.25mm_Straight
J10: 3V_CLED; Pin_Header_Straight_1x02_Pitch2.54mm
J11: MH1; MountingHole_2.7mm_M2.5_ISO14580_Pad
J12: MH2; MountingHole_2.7mm_M2.5_ISO14580_Pad
J13: MH3; MountingHole_2.7mm_M2.5_ISO14580_Pad
J14: MH4; MountingHole_2.7mm_M2.5_ISO14580_Pad
Q1, Q2, Q3, Q4: 2N3904; TO-92_Inline_Narrow_Oval
R1, R2, R3, R4, R5, R6, R9, R10, R11, R12, R23, R24, R25, R26, R27, R28, R29, R30, R31, R34: 1; R_0805_HandSoldering
R7, R32, R33, R35, R36, R37: 10k; R_0603_HandSoldering
R8, R22: 50; R_0603_HandSoldering
R13, R14, R38, R39, R40: 1M; R_0805_HandSoldering
R15, R17, R18, R19, R43, R45, R46, R47: 1k; R_0603_HandSoldering
R16, R20, R44, R48: 100; R_0603_HandSoldering
R21, R41, R42: 681; R_0603_HandSoldering
SW1: SW_Push; SW_SPST_KMR2
U1, U8: MCP1501; SOIC-8_3.9x4.9mm_Pitch1.27mm
U2, U9: MAX4080F; MSOP-8_3x3mm_Pitch0.65mm
U3, U10: LT3080; TO-220-5_Pentawatt_Multiwatt-5_Vertical_StaggeredType1
U4: dsPIC33EPXXXGP502; SOIC-28W_7.5x17.9mm_Pitch1.27mm
U5, U11: LM334Z; TO-92_Inline_Narrow_Oval
U6, U12: TLC272; SOIC-8_3.9x4.9mm_Pitch1.27mm
U7: MCP4922; SOIC-14_3.9x8.7mm_Pitch1.27mm

Connections:
+3V3: C1.1, C2.1, C3.1, C14.1, C15.1, C19.1, J7.1, J7.2, R7.1, R19.1, R35.2, R36.2, R37.2, R47.1, U1.1 (VDD), U1.3 (~SHDN), U4.13 (VDD), U7.1 (Vdd), U7.9 (~SHDN), U8.1 (VDD), U8.3 (~SHDN)
+5V: C16.1, C17.2, C22.2, J4.1, J4.2, J5.6, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, R29.2, R30.2, R31.2, R34.2, U9.1 (RS+), U9.2 (Vcc)
+12V: C4.1, C6.2, C9.2, J1.1, J1.2, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R9.2, R10.2, R11.2, R12.2, U2.1 (RS+), U2.2 (Vcc), U6.8 (V+), U12.8 (V+)
/3V_Clip: J10.1, Q4.1 (E), R47.2, U4.5 (PGEC3/V_REF_+/AN3/OA1OUT/RPI33/CTED1/RB1)
/3V_ISense: U4.3 (AN1/C2IN1+/RA1), U12.1, U12.2 (-), U12.6 (-)
/3V_ISet: U7.10 (VB), U12.5 (+)
/5V_Clip: J3.1, Q2.1 (E), R19.2, U4.4 (PGED3/V_REF_-/AN2/C2IN1-/SS1/RPI32/CTED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)
/5V_ISense: U4.2 (AN0/OA2OUT/RA0), U6.1, U6.2 (-), U6.6 (-)
/5V_ISet: U6.5 (+), U7.14 (VA)
/BTN_Btn: J6.1, R35.1, U4.11 (RP36/RB4)
/BTN_Rot1: C20.1, R32.2, U4.9 (OSC1/CLKI/RA2)
/BTN_Rot2: C21.1, R33.2, U4.10 (OSC2/CLKO/RA3)
/I2C_SCL: U4.17 (TCK/CV_REF1O_/ASCL1/SDO1/RP40/T4CK/RB8)
/I2C_SDA: U4.18 (TMS/ASDA1/SDI1/RP41/RB9)
/LED1: R42.2, U4.12 (CV_REF2O_/RP20/T1CK/RA4)
/LED2: R41.2, U4.14 (PGED2/ASDA2/RP37/RB5)
/PGM_PGEC: U4.6 (PGEC1/AN4/C1IN1+/RPI34/RB2)
/PGM_PGED: U4.7 (PGED1/AN5/C1IN1-/RP35/RB3)
/SER_RX: U4.15 (PGEC2/ASCL2/RP38/RB6)
/SER_TX: U4.16 (SCK1/RP39/INT0/RB7)
/SPI_CS_DAC: U4.24 (RPI45/CTPLS/RB13), U7.3 (~CS)
/SPI_CS_LCD: J5.1, U4.25 (RPI46/T3CK/RB14)
/SPI_SCK: J5.3, U4.22 (TDI/RP43/RB11), U7.4 (SCK)
/SPI_SDI: J5.2, U4.23 (RPI44/RB12)
/SPI_SDO: J5.4, U4.21 (TDO/RP42/RB10), U7.5 (SDI)
/Vref_DAC: R22.1, U7.11 (VrefB), U7.13 (VrefA), U8.7 (OUT), U8.8 (FB)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.1, C8.2, C9.1, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.1, C18.1, C19.2, C20.2, C21.2, C22.1, C23.2, C24.2, C25.2, D1.2 (A), D2.1 (K), D3.2 (A), J1.3, J1.4, J2.2, J2.3, J3.2, J4.3, J4.4, J5.5, J6.2, J6.4, J7.3, J7.4, J8.2, J8.4, J9.2, J9.3, J10.2, Q1.1 (E), Q2.3 (C), Q3.1 (E), Q4.3 (C), R13.2, R14.2, R20.2, R38.2, R39.2, R40.2, R48.2, SW1.1, U1.4 (GND), U1.5 (GND), U1.6 (GND), U2.4 (GND), U4.8 (VSS), U4.19 (VSS), U4.27 (AVSS), U5.3 (V-), U6.4 (V-), U7.8 (~LDAC), U7.12 (Vss), U8.4 (GND), U8.5 (GND), U8.6 (GND), U9.4 (GND), U11.3 (V-), U12.4 (V-)
unnamed: C5.1, R8.2
unnamed: C7.2, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R9.1, R10.1, R11.1, R12.1, U2.8 (RS-), U3.4 (Vcontrol), U3.5 (IN)
unnamed: C8.1, U4.20 (VCAP)
unnamed: C10.1, R13.1, R14.1, R16.2, U3.2 (SET)
unnamed: C11.1, D1.1 (K), J2.1, U3.3 (OUT), U5.1 (V+)
unnamed: C12.1, R15.2, U6.3 (+)
unnamed: C13.1, R22.2
unnamed: C18.2, R23.1, R24.1, R25.1, R26.1, R27.1, R28.1, R29.1, R30.1, R31.1, R34.1, U9.8 (RS-), U10.4 (Vcontrol), U10.5 (IN)
unnamed: C23.1, R38.1, R39.1, R40.1, R44.2, U10.2 (SET)
unnamed: C24.1, D3.1 (K), J9.1, U10.3 (OUT), U11.1 (V+)
unnamed: C25.1, R43.2, U12.3 (+)
unnamed: D2.2 (A), R21.2
unnamed: J6.3, R32.1, R36.1
unnamed: J6.5, R33.1, R37.1
unnamed: J8.1, R41.1
unnamed: J8.3, R42.1
unnamed: Q1.2 (B), R18.2
unnamed: Q1.3 (C), R16.1
unnamed: Q2.2 (B), R17.1
unnamed: Q3.2 (B), R45.2
unnamed: Q3.3 (C), R44.1
unnamed: Q4.2 (B), R46.1
unnamed: R7.2, SW1.2, U4.1 (~MCLR)
unnamed: R8.1, U1.7 (OUT), U1.8 (FB), U4.28 (AVDD)
unnamed: R15.1, U2.5 (OUT)
unnamed: R17.2, R18.1, U6.7
unnamed: R20.1, U5.2 (R)
unnamed: R21.1, U4.26 (RPI47/T5CK/RB15)
unnamed: R43.1, U9.5 (OUT)
unnamed: R45.1, R46.2, U12.7
unnamed: R48.1, U11.2 (R)

Notes on the sheet:
3.3V

Board: 2 copper layers, 107 parts (0 on the bottom side), 52 nets, no tracks yet.

## KiCad design PCB/SimpleSupply/SimpleSupply.kicad_pcb

Parts:
C2, C3, C6: 100n; C_0603_HandSoldering
C4, C7: 10µ; CP_Tantalum_Case-A_EIA-3216-18_Hand
C5, C8: 10n; C_0603_HandSoldering
D1, D2, D3: LED; LED_0603_HandSoldering
HS1, HS2: HEATSINK; Heatsink_Fischer_SK104-STCB_35x13mm__2xDrill3.5mm_ScrewM3
J1: Barrel_Jack; BARREL_JACK
J2: Vin_2; Pin_Header_Straight_1x02_Pitch2.54mm
J3: Vin_4; Pin_Header_Straight_1x04_Pitch1.27mm
J4: 5V_2; Pin_Header_Straight_1x02_Pitch2.54mm
J5: 5V_4; Pin_Header_Straight_1x04_Pitch1.27mm
J6: 3V3_2; Pin_Header_Straight_1x02_Pitch2.54mm
J7: 3V3_4; Pin_Header_Straight_1x04_Pitch1.27mm
R1: 1k; R_0603_HandSoldering
R2: 499k; R_0603_HandSoldering
R3: 390; R_0603_HandSoldering
R4: 330k; R_0603_HandSoldering
R5: 220; R_0603_HandSoldering
U1, U2: LT3080; TO-220-5_Pentawatt_Multiwatt-5_Vertical_StaggeredType1

Connections:
/3.3V: C7.1, C8.1, D3.2 (A), J6.1, J7.1, J7.2, U2.3 (OUT)
/5V: C4.1, C5.1, D2.2 (A), J4.1, J5.1, J5.2, U1.3 (OUT), U2.4 (Vcontrol), U2.5 (IN)
/Vin: C2.1, D1.2 (A), J1.1, J2.1, J3.1, J3.2, U1.4 (Vcontrol), U1.5 (IN)
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, J1.2, J2.2, J3.3, J3.4, J4.2, J5.3, J5.4, J6.2, J7.3, J7.4, R1.2, R2.2, R3.2, R4.2, R5.2
unnamed: C3.1, R2.1, U1.2 (SET)
unnamed: C6.1, R4.1, U2.2 (SET)
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), R3.1
unnamed: D3.1 (K), R5.1

Board: 2 copper layers, 43.8 x 33.7 mm, 26 parts (0 on the bottom side), 9 nets.

## Code that names these connections

File PIC/MainController.X/Settings.h:

/* 
 * File:   
 * Author: 
 * Comments:
 * Revision history: 
 */

// This is a guard condition so that contents of this file are not included
// more than once.  
#ifndef SETTINGS_H
#define	SETTINGS_H

#include <xc.h> // include processor files - each processor file is guarded.  
#include <math.h>

#define DEBUG       0           /* General debug enable                       */
#define DEBUG_I2C  (0 & DEBUG)  /* I²C debug enable                           */
#define DEBUG_FSM  (0 & DEBUG)  /* FSM debug enable                           */
#define DEBUG_SPL  (0 & DEBUG)  /* Supply debug enable                        */
#define DEBUG_LCD  (1 & DEBUG)  /* GLCD debug enable                          */

/**
 * Interrupt priorities (Highest (7) - Lowest(1))
 */

#define IP_U2RX      6
#define IP_CN        5
#define IP_MENU_TMR  4
#define IP_TMR_4     3
#define IP_I2C       2
#define IP_U1RX      1
    
/**
 * FSM TIMER CONFIG
 */
#define T4_PERIOD    60 /* In milliseconds (should be between 14us and 900ms)*/

/******************************************************************************/
/*                  PORT MAPPINGS                                             */
/******************************************************************************/  
/*  RA0 /AN0    -> LED1    
 *  RA1 /AN1    -> LED2
 *  RA2         -> ROT3-A 
 *  RA3         -> ROT3-B 
 *  RA4 /RP20   -> ROT3-D
 * 
 *  RB0 /RPI32  -> MCP_INTB
 *  RB1 /RPI33  -> MCP_INTA
 *  RB2 /RPI34  ->
 *  RB3 /RP35   ->
 *  RB4 /RP36   -> MCP_CS
 *  RB5 /RP37   -> I2C-SDA
 *  RB6 /RP38   -> I2C-SCL
 *  RB7 /RP39   -> SCK
 *  RB8 /RP40   -> SDO  
 *  RB9 /RP41   -> SDI
 *  RB10/RP42   -> ROT2-D
 *  RB11/RP43   -> ROT2-B
 *  RB12/RPI44  -> ROT2-A
 *  RB13/RPI45  -> ROT1-D
 *  RB14/RPI46  -> ROT1-B
 *  RB15/RPI47  -> ROT1-A
 * 
 */

/**
 *  PIC
 */
 
#define LED1            PORTAbits.RA0
#define LED1_Dir        TRISAbits.TRISA0
#define LED2            PORTAbits.RA1
#define LED2_Dir        TRISAbits.TRISA1
#define LED3            PORTBbits.RB0
#define LED3_Dir        TRISBbits.TRISB0
    
/**
 * UART1
 */      
// Orange = RX
// Yellow = TX
#define UART1_BAUD      57600 
#define UART1_ID        3   

#define UART1_RX_Pin    PORTBbits.RB2       /* RX Pin on RPI34-RB2           */
#define UART1_TX_Pin    PORTBbits.RB3       /* TX Pin on RP35-RB3            */
#define UART1_RX_Dir    TRISBbits.TRISB2    
#define UART1_TX_Dir    TRISBbits.TRISB3    

#define UART1_RX_Map    0b0100010           /* RX on RPI34                   */
#define UART1_TX_Map    RPOR0bits.RP35R     /* TX on RP35                    */

/**
 * UART2
 */      
// Orange = RX
// Yellow = TX
#define UART2_BAUD      19200 
#define UART2_ID        2   

#define UART2_RX_Pin    PORTBbits.RB9       /* RX Pin on RP41-RB9            */
#define UART2_TX_Pin    PORTBbits.RB8       /* TX Pin on RP40-RB8            */
#define UART2_RX_Dir    TRISBbits.TRISB9    /* RX Pin on RP41-RB9            */
#define UART2_TX_Dir    TRISBbits.TRISB8    /* TX Pin on RP40-RB8            */

#define UART2_RX_Map    0b0101001           /* RX on RP41                    */
#define UART2_TX_Map    RPOR3bits.RP40R     /* TX on RP40                    */

/**
 * I²C
 */
#define I2C_MASTER      /* Or I2C_SLAVE                                       */
#define I2C_WORD_WIDE   /* All data is send as 16-bit                         */
#define I2C2

#define I2C_SCL_Dir     TRISBbits.TRISB6        /* SCL Direction              */
#define I2C_SDA_Dir     TRISBbits.TRISB5        /* SDA Direction              */

#define I2C_SCL_Odc     ODCBbits.ODCB6          /* Open drain config for SCL  */
#define I2C_SDA_Odc     ODCBbits.ODCB5          /* Open drain config for SDA  */
 

/**
 * ROTARY ENCODERS
 */
#define ROT1_A_Pin      PORTBbits.RB15
#define ROT1_A_Dir      TRISBbits.TRISB15
#define ROT1_A_Int      CNENBbits.CNIEB15 
#define ROT1_B_Pin      PORTBbits.RB14
#define ROT1_B_Dir      TRISBbits.TRISB14
#define ROT1_B_Int      CNENBbits.CNIEB14 
#define ROT1_D_Pin      PORTBbits.RB13
#define ROT1_D_Dir      TRISBbits.TRISB13
#define ROT1_D_Int      CNENBbits.CNIEB13

#define ROT2_A_Pin      PORTBbits.RB12
#define ROT2_A_Dir      TRISBbits.TRISB12
#define ROT2_A_Int      CNENBbits.CNIEB12 
#define ROT2_B_Pin      PORTBbits.RB11
#define ROT2_B_Dir      TRISBbits.TRISB11
#define ROT2_B_Int      CNENBbits.CNIEB11 
#define ROT2_D_Pin      PORTBbits.RB10
#define ROT2_D_Dir      TRISBbits.TRISB10
#define ROT2_D_Int      CNENBbits.CNIEB10

#define ROT3_A_Pin      PORTAbits.RA4
#define ROT3_A_Dir      TRISAbits.TRISA4
#define ROT3_A_Int      CNENAbits.CNIEA4 
#define ROT3_B_Pin      PORTAbits.RA3
#define ROT3_B_Dir      TRISAbits.TRISA3
#define ROT3_B_Int      CNENAbits.CNIEA3 
#define ROT3_D_Pin      PORTAbits.RA2
#define ROT3_D_Dir      TRISAbits.TRISA2
#define ROT3_D_Int      CNENAbits.CNIEA2

#endif	/* XC_HEADER_TEMPLATE_H */

File PIC/PowerSupply_lcd_V2.X/Settings.h:

/* 
 * File:   
 * Author: 
 * Comments:
 * Revision history: 
 */

// This is a guard condition so that contents of this file are not included
// more than once.  
#ifndef SETTINGS_H
#define	SETTINGS_H

#include <xc.h> // include processor files - each processor file is guarded.  

#define DEBUG       1           /* General debug enable                       */
#define DEBUG_I2C  (1 & DEBUG)  /* I²C debug enable                           */
#define DEBUG_FSM  (1 & DEBUG)  /* FSM debug enable                           */

/**
 * Interrupt priorities (Highest (7) - Lowest(1))
 */

#define IP_U1RX      6
#define IP_I2C       5
#define IP_MENU_TMR  2
#define IP_MAIN_TMR  1
    
/**
 *  PIC
 */
 
#define LED1            PORTAbits.RA0
#define LED1_Dir        TRISAbits.TRISA0
#define LED2            PORTAbits.RA1
#define LED2_Dir        TRISAbits.TRISA1
#define LED3            PORTBbits.RB0
#define LED3_Dir        TRISBbits.TRISB0
    
/**
 * UART
 */      
#define UART1_BAUD      57600 /* 57600 */
#define UART1_ID        2   

#define UART1_RX_Dir    TRISBbits.TRISB4    /* RX Pin on RP36-RB4             */
#define UART1_TX_Dir    TRISAbits.TRISA4    /* TX Pin on RP20-RA4             */

#define UART1_RX_Map    0b0100100           /* RX on RP36                     */
#define UART1_TX_Map    RPOR0bits.RP20R     /* TX on RP20                     */

/**
 * MCP
 */
#define MCP_CS          PORTBbits.RB1
#define MCP_CS_Dir      TRISBbits.TRISB1
#define MCP_ADDR        0b01000000

#define MCP_INTA        PORTBbits.RB14
#define MCP_INTA_Dir    TRISBbits.TRISB14
#define MCP_INTA_Pu     CNPUBbits.CNPUB14

#define MCP_INTB        PORTBbits.RB15
#define MCP_INTB_Dir    TRISBbits.TRISB15
#define MCP_INTB_Pu     CNPUBbits.CNPUB15

/**
 * LCD
 */
#define LCD_SS_Dir      TRISBbits.TRISB13       /* SS on pin RB10             */
#define LCD_SS_Pin      PORTBbits.RB13          /* SS pin                     */

/**
 *  SPI1
 */
    
#define SPI1_SCK_Dir    TRISBbits.TRISB7        /* SCK pin on RB7             */
#define SPI1_SDO_Dir    TRISBbits.TRISB8        /* SDO pin on RB8             */
#define SPI1_SDI_Dir    TRISBbits.TRISB9        /* SDI pin on RB9             */

/**
 *  SPI2
 */
    
#define SPI2_SCK_Dir    TRISBbits.TRISB10       /* SCK pin on RB7             */
#define SPI2_SDO_Dir    TRISBbits.TRISB11       /* SDO pin on RB8             */
#define SPI2_SDI_Dir    TRISBbits.TRISB12       /* SDI pin on RB9             */

#define SPI2_SCK_Map    RPOR4bits.RP42R         /* RP42 Pin Assignment  SCK   */
#define SPI2_SDO_Map    RPOR4bits.RP43R         /* RP43 Pin Assignment  SDO   */
#define SPI2_SDI_Map    0b0101100               /* RPI44 Pin Assignment SDI   */

/**
 * I²C
 */
#define I2C_ADDRESS     0x03

#define I2C_SCL_Dir     TRISBbits.TRISB6        /* SCL Direction              */
#define I2C_SDA_Dir     TRISBbits.TRISB5        /* SDA Direction              */

#define I2C_SCL_Odc     ODCBbits.ODCB6          /* Open drain config for SCL  */
#define I2C_SDA_Odc     ODCBbits.ODCB5          /* Open drain config for SDA  */

/**
 * ENCODER
 */

    

#endif	/* XC_HEADER_TEMPLATE_H */

File PIC/PowerSupply_lcd_V2/Settings.h:

/* 
 * File:   
 * Author: 
 * Comments:
 * Revision history: 
 */

// This is a guard condition so that contents of this file are not included
// more than once.  
#ifndef SETTINGS_H
#define	SETTINGS_H

#include <xc.h> // include processor files - each processor file is guarded.  

#define DEBUG       1

/**
 * Interrupt priorities
 */

#define CN_IP       2     
#define T2_IP       1  
#define U1RX_IP     3
    
/**
 *  PIC
 */
 
#define LED1            PORTBbits.RB15
#define LED1_Dir        TRISBbits.TRISB15
#define LED2            PORTBbits.RB14
#define LED2_Dir        TRISBbits.TRISB14
    
/**
 * UART
 */      
#define UART1_BAUD      57600 /* 57600 */
#define UART1_ID        2   

#define UART1_RX_Dir    TRISBbits.TRISB6    /* RX Pin on RP38-RB6             */
#define UART1_TX_Dir    TRISBbits.TRISB5    /* TX Pin on RP37-RB5             */

#define UART1_RX_Map    0b0100110           /* RX on RP38                     */
#define UART1_TX_Map    RPOR1bits.RP37R     /* TX on RP37                     */

/**
 *  SPI
 */
    
#define SPI2_SCK_Dir    TRISBbits.TRISB10       /* SCK pin on RB7             */
#define SPI2_SDO_Dir    TRISBbits.TRISB11       /* SDO pin on RB8             */
#define SPI2_SDI_Dir    TRISBbits.TRISB12       /* SDI pin on RB9             */

#define SPI2_SS_Dir     TRISBbits.TRISB13       /* SS on pin RB10             */
#define SPI2_SS_Pin     PORTBbits.RB13          /* SS pin                     */

#define SPI2_SCK_Map    RPOR4bits.RP42R         /* RP42 Pin Assignment  SCK   */
#define SPI2_SDO_Map    RPOR4bits.RP43R         /* RP43 Pin Assignment  SDO   */
#define SPI2_SDI_Map    0b0101100               /* RPI44 Pin Assignment SDI   */

/**
 * I²C
 */
#define I2C_ADDRESS     0x03

#define I2C_SCL_Dir     TRISBbits.TRISB8        /* SCL Direction              */
#define I2C_SDA_Dir     TRISBbits.TRISB9        /* SDA Direction              */

#define I2C_SCL_Odc     ODCBbits.ODCB8          /* Open drain config for SCL  */
#define I2C_SDA_Odc     ODCBbits.ODCB9          /* Open drain config for SDA  */

/**
 * ENCODER
 */
#define ENC_A_Dir       TRISBbits.TRISB0
#define ENC_B_Dir       TRISBbits.TRISB1
#define ENC_A_Pin       PORTBbits.RB0
#define ENC_B_Pin       PORTBbits.RB1

#define ENC_BTN_Dir     TRISAbits.TRISA0
#define ENC_BTN_Pin     PORTAbits.RA0
    

#endif	/* XC_HEADER_TEMPLATE_H */

## Commit log

2017-05-04 Created project
2017-05-04 added files
2017-05-07 added PIC code
2017-05-12 Added PIC projects and I2C interface
2017-05-14 added lcd driver
2017-05-14 before interrupts driven read
2017-05-14 I2C read and write working
2017-05-14 rotary encoder
2017-05-20 added MCP4131 controll
2017-05-21 menus with pointers and structs is too complex
2017-05-23 lcd controllers
2017-05-25 Bringing it all together
2017-07-11 commit uncomitted and add pcb
2017-07-11 Change footprints, add serial leds
2017-07-11 component layout done
2017-07-11 Pcb layout V2 ready
2017-07-11 lcd pcdb
2017-12-25 Pic code for variable with correct output pins
2018-02-17 next pcb version
2018-02-18 a lot of version 2 stuff
2018-02-22 added new menu stuff
2018-02-24 added v2 of variable and lcd board
2018-03-01 better i2c
2018-03-10 basics for pic done
2018-03-18 first application + uart api
2018-03-26 new software, reorden pcb layout
2018-03-26 voltage sweep on new pcb
2018-04-08 working version
2018-05-12 commit before adc refactor
2018-06-11 lcd pcb
2018-06-12 pcb lcd
2018-06-12 add ignore
2018-06-12 ignore file
2018-06-13 create main pcb
2018-06-14 clean up main controller pcb
2018-06-28 unwanted modifs?
2018-07-06 opening mplab
2018-07-06 build main lcd
2018-07-06 BEFORE NEW MAIN
2018-07-06 new fsm for user input and lcd
2018-07-09 updated pcb for MPC23S power supply error
2018-07-09 added menu logic for new FSM
2018-07-09 new fsm
2018-07-09 test menu
2018-07-10 more on FSM
2018-07-10 build
2018-07-10 updated ignore file
2018-07-11 fixed gitignore
2018-07-11 i2c stuff
2018-07-11 settings
2018-07-12 encoder other possibilities
2018-07-12 read new ignore
2018-07-16 iic slave
2018-07-16 adding new iic interface
2018-07-20 created new projects
2018-07-21 new adc and communication
2018-07-21 needed to make new projects
2018-07-24 add status to i2c communication
2018-07-24 sending status
2018-07-24 old version
2018-07-25 calibration
2018-07-25 merge
2018-07-26 calibrate fsm
2018-07-27 update status in salve
2018-07-27 salve i2c with buffer address in stead of command
2018-07-30 menus and calibration
2018-07-30 revert commit
2018-07-31 menu change contrast and brightness
2018-07-31 errors
2019-04-15 added description and windows builds
2019-04-15 update document
2019-04-15 updated some unimportant files
2019-06-16 documentation and review of project
2019-06-16 removed old doc
2019-06-16 update doc
2019-06-19 update docs
2020-04-04 commit before starting with GLCD
2020-04-07 edit gitignore
2020-04-07 Make the menu controller work
2020-04-07 ready for other controller
2020-04-07 copy old MainController
2020-04-07 prepare main controller
2020-04-14 maincontroller
2020-04-18 gitignore
2020-04-18 Write to GLCD driver
2020-04-19 clean up MainController project
2020-04-19 Rotary encoder driver
2020-04-19 remove unused files
2020-04-19 FSM controllers
2020-05-08 main glcd controller pcb
2020-05-09 prepare stuff for new GLCD
2020-05-10 create GLCD lib
2020-05-11 testing labels and text
2020-05-11 saleae settings for uart
2020-05-15 GLCD controller
2020-05-15 header file GLCD
2020-05-16 GLCD19264 functions
2020-05-17 drivers and screen layout
2020-05-17 added lib files
2020-05-18 fsm stuff
2020-05-20 good code for controller
2020-05-20 setup works!!!!!!!
2020-05-20 clean up
2020-05-20 supplies OK!
2020-05-21 bitmaps
2020-05-21 add connected flag
2020-05-22 better menu
2020-05-23 temparature
2020-06-06 main pcb
