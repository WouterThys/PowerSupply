# Repository WouterThys/PowerSupply

## KiCad design PCB/MainController/MainController.kicad_pcb

Parts:
C1, C4, C7: 1µ; CP_Tantalum_Case-A_EIA-3216-18_Reflow
C2, C3, C10, C11, C12: 10n; C_0603_HandSoldering
C5: 10µ; CP_Tantalum_Case-A_EIA-3216-18_Reflow
C6, C8, C9: 100n; C_0603_HandSoldering
D1: D; D_1206
D2, D3, D4, D5, D6, D7: LED; LED_0603_HandSoldering
J1: 5V; Pin_Header_Straight_1x04_Pitch2.54mm
J2: PGM; Pin_Header_Straight_1x05_Pitch2.54mm
J3: SERIAL; Molex_PicoBlade_53047-0410_04x1.25mm_Straight
J4: I2C; Molex_PicoBlade_53047-0410_04x1.25mm_Straight
J5: IO; Molex_PicoBlade_53047-0810_08x1.25mm_Straight
J6: PWR; Molex_PicoBlade_53047-0410_04x1.25mm_Straight
J7, J8, J9, J11, J12: MH; MountingHole_2.7mm_M2.5_ISO14580_Pad
J10: Jack-DC; BARREL_JACK
J13: PIC_IO; Pin_Header_Straight_1x05_Pitch2.54mm
R1, R3, R8, R9, R10, R11, R12, R13: 10k; R_0603_HandSoldering
R2, R14, R15, R16: 2.87k; R_0603_HandSoldering
R4, R5: 2k87; R_0603_HandSoldering
R6, R7: 2k16; R_0603_HandSoldering
SW1: SW_Push; SW_PUSH_6mm
SW2, SW3, SW4, SW5: SW; mySW_PUSH_6mm
SW6: Rotary; ALPS_STEC12E08
U1: NHD-0216K3Z; WC1602A
U2: MCP1700; TO-92_Inline_Narrow_Oval
U3: dsPIC33EPXXXGP502; SOIC-28W_7.5x17.9mm_Pitch1.27mm
U4: MCP23S17; SOIC-28W_7.5x17.9mm_Pitch1.27mm

Connections:
+3V3: C1.1, C3.1, C7.1, C8.1, J2.2, J4.1, J6.3, J6.4, J13.1, R1.1, R2.2, R6.2, R7.2, U2.3 (VO), U3.13 (VDD), U3.28 (AVDD)
/BTN0: SW2.1, U4.1 (GPB0)
/BTN1: SW3.1, U4.2 (GPB1)
/BTN2: SW4.1, U4.3 (GPB2)
/BTN3: SW5.1, U4.4 (GPB3)
/GPA0: J5.8, U4.21 (GPA0)
/GPA1: J5.7, U4.22 (GPA1)
/GPA2: J5.6, U4.23 (GPA2)
/GPA3: J5.5, U4.24 (GPA3)
/GPA4: J5.4, U4.25 (GPA4)
/GPA5: J5.3, U4.26 (GPA5)
/GPA6: J5.2, U4.27 (GPA6)
/GPA7: J5.1, U4.28 (GPA7)
/I2C_SCL: J4.3, R7.1, U3.15 (PGEC2/ASCL2/RP38/RB6)
/I2C_SDA: J4.2, R6.1, U3.14 (PGED2/ASDA2/RP37/RB5)
/IO_CS: U3.5 (PGEC3/V_REF_+/AN3/OA1OUT/RPI33/CTED1/RB1), U4.11 (~CS)
/IO_INTA: U3.25 (RPI46/T3CK/RB14), U4.19 (INTB)
/IO_INTB: U3.26 (RPI47/T5CK/RB15), U4.20 (INTA)
/IO_SCK: U3.16 (SCK1/RP39/INT0/RB7), U4.12 (SCK)
/IO_SDI: U3.18 (TMS/ASDA1/SDI1/RP41/RB9), U4.14 (SO)
/IO_SDO: U3.17 (TCK/CV_REF1O_/ASCL1/SDO1/RP40/T4CK/RB8), U4.13 (SI)
/LCD_SCK: U1.6 (SCK/SCL), U3.21 (TDO/RP42/RB10)
/LCD_SDI: U1.5 (SDO), U3.23 (RPI44/RB12)
/LCD_SDO: U1.7 (SDI/SDA), U3.22 (TDI/RP43/RB11)
/LCD_SS: U1.4 (SPISS), U3.24 (RPI45/CTPLS/RB13)
/PGM_PGEC: J2.5, U3.6 (PGEC1/AN4/C1IN1+/RPI34/RB2)
/PGM_PGED: J2.4, U3.7 (PGED1/AN5/C1IN1-/RP35/RB3)
/RA0: J13.3, R14.2, U3.2 (AN0/OA2OUT/RA0)
/RA1: J13.4, R15.2, U3.3 (AN1/C2IN1+/RA1)
/RB0: J13.5, R16.2, U3.4 (PGED3/V_REF_-/AN2/C2IN1-/SS1/RPI32/CTED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)
/RESET: J2.1, R1.2, SW1.2, U3.1 (~MCLR), U4.18 (~RESET)
/ROT_B1: C12.1, R13.1, U4.6 (GPB5)
/ROT_R1: C10.2, R8.2, U4.8 (GPB7)
/ROT_R2: C11.1, R9.2, U4.7 (GPB6)
/SER_RX: J3.3, R3.2, R5.2, U3.11 (RP36/RB4)
/SER_TX: J3.2, R4.2, U3.12 (CV_REF2O_/RP20/T1CK/RA4)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.1, C11.2, C12.2, D1.2 (A), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), J1.3, J1.4, J2.3, J3.4, J4.4, J6.1, J6.2, J10.2, J10.3, J13.2, R3.1, SW1.1, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2 (C), SW6.5, U1.8 (Vss), U2.1 (GND), U3.8 (VSS), U3.19 (VSS), U3.27 (AVSS), U4.10 (GND), U4.15 (A0), U4.16 (A1), U4.17 (A2); also elsewhere on the board
unnamed: C5.1, U3.20 (VCAP)
unnamed: D2.2 (A), R2.1
unnamed: D3.2 (A), R4.1
unnamed: D4.2 (A), R5.1
unnamed: D5.2 (A), R16.1
unnamed: D6.2 (A), R15.1
unnamed: D7.2 (A), R14.1
unnamed: R8.1, R10.2, SW6.1 (A)
unnamed: R9.1, R11.1, SW6.3 (B)
unnamed: R12.2, R13.2, SW6.4

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
Board: 2 copper layers, 124.0 x 48.0 mm, 61 parts (6 on the bottom side), 49 nets.

Other parts of the board:
C13: 100n; C_0603_HandSoldering
C14: 1µ; CP_Tantalum_Case-A_EIA-3216-18_Reflow
U5: MCP1700; TO-92_Inline_Narrow_Oval

Their connections:
GND: C13.2, C14.2, U5.1; also elsewhere on the board

## KiCad design PCB/V1/SupplyMainDigital.kicad_pcb

Parts:
C1, C2, C10, C11, C12, C13, C14: 1µ; C_0603_HandSoldering
C3, C4: 10n; C_0603_HandSoldering
C5, C6: 2.2µ **; CP_Tantalum_Case-A_EIA-3216-18_Reflow
C7, C9: 100n; C_0603_HandSoldering
C8: 10µ **; CP_Tantalum_Case-A_EIA-3216-18_Reflow
CON1: BARREL_JACK
D1, D2, D4, D5, D6: LED; LED_0603
D3: D_Zener; D_5W_P10.16mm_Horizontal
HS1: HEATSINK; Heatsink_Fischer_SK104-STCB_35x13mm__2xDrill3.5mm_ScrewM3
P1: 12V; Pin_Header_Straight_1x02_Pitch2.54mm
P2: 5V; Pin_Header_Straight_1x02_Pitch2.54mm
P3: 3V3; Pin_Header_Straight_1x02_Pitch2.54mm
P4: GND; Pin_Header_Straight_1x04_Pitch2.54mm
P5: PGM; Pin_Header_Angled_1x05_Pitch2.00mm
P6: SERIAL; Molex_PicoBlade_53047-0410_04x1.25mm_Straight
P7: I2C; Molex_PicoBlade_53047-0410_04x1.25mm_Straight
P8: OUT; AK300-2
R1, R2: 1k; R_0603_HandSoldering
R3, R4: 50; R_0603_HandSoldering
R5: 10k; R_0603_HandSoldering
R6, R7, R8, R9, R27, R28, R29, R30, R31: 10k**; R_0603_HandSoldering
R10, R11, R26, R38, R39, R40: 100; R_0603_HandSoldering
R12, R13: 2k2; R_0603_HandSoldering
R14, R15, R16, R17, R18, R19, R20, R21, R22, R23: 10**; R_0805_HandSoldering
R24, R25: 100**; R_0603_HandSoldering
R34: 2.2k; R_0603_HandSoldering
R35: R; R_0603_HandSoldering
R36: 0; R_0603_HandSoldering
R37: 200k; R_0603_HandSoldering
SW1: SW_PUSH; SW_SPST_B3S-1000
TP1, TP2, TP3, TP6, TP7, TP8, TP9, TP12: TEST; Measurement_Point_Round-SMD-Pad_Small
U1: TLC272; TSSOP-8_4.4x3mm_Pitch0.65mm
U2, U3: MCP1501; SOIC-8_3.9x4.9mm_Pitch1.27mm
U4: TLV5616C; SOIC-8_3.9x4.9mm_Pitch1.27mm
U5: dsPIC33EPXXXGP502; SOIC-28W_7.5x17.9mm_Pitch1.27mm
U6: LT3081; TO-220-7_Multiwatt-7_Vertical_StaggeredType1
U7: MCP4131; MSOP-8_3x3mm_Pitch0.65mm
U8: LM334Z; TO-92_Inline_Narrow_Oval
U9: MAX4080; MSOP-8_3x3mm_Pitch0.65mm

Connections:
+3V3: C1.1, C2.1, C3.1, C4.1, C9.1, P3.1, P3.2, P5.2, P6.1, P7.1, R5.2, R12.1, R13.1, U2.1 (VDD), U2.3 (~SHDN), U3.1 (VDD), U3.3 (~SHDN), U4.8 (VDD), U5.13 (VDD), U7.8 (VDD); also elsewhere on the board
+5V: P2.1, P2.2; also elsewhere on the board
+12V: C7.1, C11.1, P1.1, P1.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, U1.8, U9.1 (RS+), U9.2 (VCC); also elsewhere on the board
/3081_IN: C12.1, R14.1, R15.1, R16.1, R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, R23.1, U6.6 (IN), U9.8 (RS-)
/DAC_OUT: U1.5, U4.7 (OUT)
/I2C_SCL: P7.2, R12.2, U5.17 (TCK/CV_REF1O_/ASCL1/SDO1/RP40/T4CK/RB8)
/I2C_SDA: P7.3, R13.2, U5.18 (TMS/ASDA1/SDI1/RP41/RB9)
/IMON: R35.1, TP9.1, U5.5 (PGEC3/V_REF_+/AN3/OA1OUT/RPI33/CTED1/RB1), U6.3 (IMON)
/PGM_PGEC: P5.5, U5.6 (PGEC1/AN4/C1IN1+/RPI34/RB2)
/PGM_PGED: P5.4, U5.7 (PGED1/AN5/C1IN1-/RP35/RB3)
/Power/Pin: CON1.1; also elsewhere on the board
/RESET: P5.1, R5.1, SW1.2, U5.1 (~MCLR)
/SER_RX: P6.3, R39.2, U5.15 (PGEC2/ASCL2/RP38/RB6)
/SER_TX: P6.2, R38.2, U5.16 (SCK1/RP39/INT0/RB7)
/SET: C10.1, R7.2, TP3.1, U1.7, U6.2 (SET)
/SPI_CS_DAC: U4.3 (~CS), U5.12 (CV_REF2O_/RP20/T1CK/RA4)
/SPI_CS_MCP: U5.11 (RP36/RB4), U7.1 (~CS)
/SPI_FS: U4.4 (FS), U5.14 (PGED2/ASDA2/RP37/RB5)
/SPI_SCK: U4.2 (SCLK), U5.22 (TDI/RP43/RB11), U7.2 (SCK)
/SPI_SDI: R37.1, U5.23 (RPI44/RB12), U7.3 (SDI/SDO)
/SPI_SDO: R37.2, U4.1 (DIN), U5.21 (TDO/RP42/RB10)
/TEMP: R34.1, TP8.1, U5.4 (PGED3/V_REF_-/AN2/C2IN1-/SS1/RPI32/CTED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), U6.5 (TEMP)
/VO+: D3.1 (K), P8.1, R27.1, R29.1, R30.1, R31.1, TP12.1, U6.4 (OUT), U7.6 (P0W), U8.1 (V+)
/VO_SENSE: C14.1, R27.2, R28.1, R29.2, R30.2, R31.2, TP6.1, U5.2 (AN0/OA2OUT/RA0)
/VSENSE: C13.1, R26.1, TP7.1, U5.3 (AN1/C2IN1+/RA1)
GND: C1.2, C2.2, C3.2, C4.2, C8.2, C9.2, D1.1 (K), D2.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), P5.3, P6.4, P7.4, R36.2, SW1.1, U5.8 (VSS), U5.19 (VSS), U7.4 (VSS)
GNDA: C5.2, C6.2, C7.2, C10.2, C11.2, C12.2, C13.2, C14.2, CON1.2, D3.2 (A), P4.1, P4.2, P4.3, P4.4, P8.2, R1.2, R2.2, R6.1, R8.1, R9.1, R24.2, R25.2, R28.2, R34.2, R35.2, R36.1, U1.4, U2.4 (GND), U2.5 (GND), U2.6 (GND), U3.4 (GND), U3.5 (GND), U3.6 (GND), U4.5 (AGND), U5.27 (AVSS), U8.3 (V-), U9.4 (GND); also elsewhere on the board
unnamed: C5.1, R3.2
unnamed: C6.1, R4.2
unnamed: C8.1, U5.20 (VCAP)
unnamed: D1.2 (A), R10.2
unnamed: D2.2 (A), R11.2
unnamed: D4.2 (A), R38.1
unnamed: D5.2 (A), R39.1
unnamed: D6.2 (A), R40.2
unnamed: R1.1, R3.1, TP1.1, U2.7 (OUT), U2.8 (FB), U5.28 (AVDD)
unnamed: R2.1, R4.1, TP2.1, U3.7 (OUT), U3.8 (FB), U4.6 (REFIN)
unnamed: R6.2, R7.1, R8.2, R9.2, U1.6
unnamed: R10.1, U5.26 (RPI47/T5CK/RB15)
unnamed: R11.1, U5.25 (RPI46/T3CK/RB14)
unnamed: R24.1, R25.1, U8.2 (R)
unnamed: R26.2, U9.5 (OUT)
unnamed: R40.1, U5.24 (RPI45/CTPLS/RB13)
unnamed: U6.1 (ILIM), U7.7 (P0B)

Notes on the sheet:
DAC out (max) 4.048V Gain of 3 -> Vout (max) = 12.288V
Star gnd
11/07/2017
* Different PIC pins for serial and spi * LED's on Serial lines
12V DC input

Board: 2 copper layers, 79.0 x 57.0 mm, 102 parts (0 on the bottom side), 46 nets.

Other parts of the board:
C15: 10µ; C_0603_HandSoldering
C16: 100n; C_0603_HandSoldering
C17, C19: 1µ**; CP_Tantalum_Case-A_EIA-3216-18_Reflow
C18, C20: 2.2µ **; CP_Tantalum_Case-A_EIA-3216-18_Reflow
F1: Fuse; Fuseholder5x20_horiz_SemiClosed_Casing10x25mm
HS2, HS3: HEATSINK; Heatsink_Fischer_SK104-STCB_35x13mm__2xDrill3.5mm_ScrewM3
R32: 500K*; R_0603_HandSoldering
R33: 330K*; R_0603_HandSoldering
TP13, TP14, TP16: TEST; Measurement_Point_Round-SMD-Pad_Small
U10, U11: LT3080; TO-220-5_Pentawatt_Multiwatt-5_Vertical_StaggeredType1

Their connections:
+3V3: C20.1, U11.3; also elsewhere on the board
+5V: C18.1, U10.3, U11.4, U11.5; also elsewhere on the board
+12V: C15.1, C16.1, F1.1, TP13.1, U10.4, U10.5; also elsewhere on the board
/Power/Pin: F1.2; also elsewhere on the board
GNDA: C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, R32.2, R33.2; also elsewhere on the board
unnamed: C17.1, R32.1, TP14.1, U10.2
unnamed: C19.1, R33.1, TP16.1, U11.2

## KiCad design PCB/V3/SupplyMainDigital.kicad_pcb

Parts:
C1, C2: 1µ; C_0603_HandSoldering
C3, C4: 10n; C_0603_HandSoldering
C5, C6: 2.2µ; CP_Tantalum_Case-A_EIA-3216-18_Hand
C7, C9, C11, C13, C14, C21, C22: 100n; C_0603_HandSoldering
C8, C10, C12, C23: 10µ; CP_Tantalum_Case-A_EIA-3216-18_Hand
C15, C16: 1µ; CP_Tantalum_Case-A_EIA-3216-18_Hand
D1, D2, D4, D5, D6, D7: LED; LED_0603_HandSoldering
D3: D_Zener; D_5W_P10.16mm_Horizontal
HS1: HEATSINK; Heatsink_Fischer_SK104-STCB_35x13mm__2xDrill3.5mm_ScrewM3
J1: IN; BARREL_JACK
J2: 3.3V; Molex_PicoBlade_53047-0410_04x1.25mm_Straight
J3: OUT; BARREL_JACK
J4, J5, J6, J7: Conn_01x01; MountingHole_2.7mm_M2.5_ISO14580_Pad
JP3, JP6: Pin_Header_Straight_1x02_Pitch2.54mm
JP5: Ilim; Pin_Header_Straight_1x02_Pitch2.54mm
P1: LEDs; Molex_PicoBlade_53047-0410_04x1.25mm_Straight
P5: PGM; Pin_Header_Straight_1x05_Pitch2.54mm
P6: SERIAL; Molex_PicoBlade_53047-0410_04x1.25mm_Straight
P7: I2C; Molex_PicoBlade_53047-0410_04x1.25mm_Straight
Q1, Q2: 2N3904; TO-92_Molded_Narrow
R1: 2.2k; R_0603_HandSoldering
R2, R5, R6, R7, R8, R9, R25, R28, R30, R31, R33, R37, R41: 10k; R_0603_HandSoldering
R3, R4: 50; R_0603_HandSoldering
R10, R11, R38, R39, R40: 196; R_0603_HandSoldering
R12, R13: 2k2; R_0603_HandSoldering
R14, R15, R16, R17, R18, R19, R20, R21, R22, R23: 1; R_0805_HandSoldering
R24, R27: 100; R_0603_HandSoldering
R26, R29, R32, R36: 1k; R_0603_HandSoldering
R34: 68k; R_0603_HandSoldering
R35: 5.1k; R_0603_HandSoldering
SW1: SW_PUSH; SW_SPST_KMR2
U1, U12: TLC272; SOIC-8_3.9x4.9mm_Pitch1.27mm
U2, U3: MCP1501; SOIC-8_3.9x4.9mm_Pitch1.27mm
U4: MCP4922; SOIC-14_3.9x8.7mm_Pitch1.27mm
U5: dsPIC33EPXXXGP502; SOIC-28W_7.5x17.9mm_Pitch1.27mm
U6: LT3081; TO-220-7_Multiwatt-7_Vertical_StaggeredType1
U8: LM334Z; TO-92_Inline_Narrow_Oval
U9: MAX4080; MSOP-8_3x3mm_Pitch0.65mm

Connections:
+3V3: C1.1, C2.1, C3.1, C4.1, C9.1, C10.1, C16.1, J2.1, J2.2, P5.2, P7.1, R5.2, R12.1, R13.1, R29.1, U2.1 (VDD), U2.3 (~SHDN), U3.1 (VDD), U3.3 (~SHDN), U4.1 (Vdd), U4.9 (~SHDN), U5.13 (VDD)
+12V: C7.1, C11.1, C14.1, C15.1, J1.1, R1.1, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, U1.8 (Vdd), U9.1 (RS+), U9.2 (VCC), U12.8 (V+)
/3081_IN: C13.1, R14.1, R15.1, R16.1, R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, R23.1, U6.6 (IN), U9.8 (RS-)
/CLIP: Q2.3 (C), R29.2, U5.14 (PGED2/ASDA2/RP37/RB5)
/I2C_SCL: P7.3, R13.2, U5.17 (TCK/CV_REF1O_/ASCL1/SDO1/RP40/T4CK/RB8)
/I2C_SDA: P7.2, R12.2, U5.18 (TMS/ASDA1/SDI1/RP41/RB9)
/IMON: R35.1, U5.5 (PGEC3/V_REF_+/AN3/OA1OUT/RPI33/CTED1/RB1), U6.3 (IMON)
/Iset: U1.6 (-), U4.10 (VB)
/PGM_PGEC: P5.5, U5.6 (PGEC1/AN4/C1IN1+/RPI34/RB2)
/PGM_PGED: P5.4, U5.7 (PGED1/AN5/C1IN1-/RP35/RB3)
/RESET: P5.1, R5.1, SW1.2, U5.1 (~MCLR)
/SER_RX: P6.3, R30.2, R39.2, U5.15 (PGEC2/ASCL2/RP38/RB6)
/SER_TX: P6.2, R38.2, U5.16 (SCK1/RP39/INT0/RB7)
/SET: C12.1, R7.2, R27.2, U6.2 (SET)
/SPI_CS_DAC: U4.3 (~CS), U5.12 (CV_REF2O_/RP20/T1CK/RA4)
/SPI_SCK: U4.4 (SCK), U5.22 (TDI/RP43/RB11)
/SPI_SDO: U4.5 (SDI), U5.21 (TDO/RP42/RB10)
/TEMP: R34.1, U5.4 (PGED3/V_REF_-/AN2/C2IN1-/SS1/RPI32/CTED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), U6.5 (TEMP)
/VSENSE: U1.5 (+), U5.3 (AN1/C2IN1+/RA1), U12.6 (-), U12.7
/Vref_DAC: R4.1, U3.7 (OUT), U3.8 (FB), U4.11 (VrefB), U4.13 (VrefA)
/Vset: U1.3 (+), U4.14 (VA)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C21.2, C22.2, C23.2, D1.1 (K), D2.1 (K), D3.2 (A), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), J1.2, J1.3, J2.3, J2.4, J3.2, J3.3, P1.1, P5.3, P6.4, P7.4, Q1.1 (E), Q2.1 (E), R8.2, R9.2, R24.2, R30.1, R31.1, R33.1, R34.2, R35.2, R37.1, R41.1, SW1.1, U1.4 (GND), U2.4 (GND), U2.5 (GND), U2.6 (GND), U3.4 (GND), U3.5 (GND), U3.6 (GND), U4.8 (~LDAC), U4.12 (Vss), U5.8 (VSS), U5.19 (VSS), U5.27 (AVSS), U8.3 (V-), U9.4 (GND), U12.4 (V-)
unnamed: C5.1, R3.2
unnamed: C6.1, R4.2
unnamed: C8.1, U5.20 (VCAP)
unnamed: C21.1, R32.1, U12.5 (+)
unnamed: C22.1, R36.2, U12.3 (+)
unnamed: C23.1, D3.1 (K), J3.1, JP5.2, JP6.2, U6.4 (OUT)
unnamed: D1.2 (A), R10.2
unnamed: D2.2 (A), R11.2
unnamed: D4.2 (A), R38.1
unnamed: D5.2 (A), R39.1
unnamed: D6.2 (A), R40.2
unnamed: D7.2 (A), R1.2
unnamed: JP3.1, Q1.3 (C)
unnamed: JP3.2, R26.2, R27.1
unnamed: JP5.1, U8.1 (V+)
unnamed: JP6.1, R2.2
unnamed: P1.2, R10.1, U5.26 (RPI47/T5CK/RB15)
unnamed: P1.3, R11.1, U5.25 (RPI46/T3CK/RB14)
unnamed: P1.4, R40.1, U5.24 (RPI45/CTPLS/RB13)
unnamed: Q1.2 (B), R25.2
unnamed: Q2.2 (B), R28.2
unnamed: R2.1, R31.2, R33.2, R36.1, R37.2, R41.2
unnamed: R3.1, U2.7 (OUT), U2.8 (FB), U5.28 (AVDD)
unnamed: R6.1, R8.1, R9.1, U1.2 (-)
unnamed: R6.2, R7.1
unnamed: R24.1, U8.2 (R)
unnamed: R25.1, R28.1, U1.7
unnamed: R26.1, U1.1
unnamed: R32.2, U9.5 (OUT)

Notes on the sheet:
Gain of 5 DAC out (max) 2.048V -> Vout (max) = 10.24V
LPF
Vout
LIM
Gain of 1/5

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
Board: 2 copper layers, 64.0 x 48.0 mm, 94 parts (0 on the bottom side), 52 nets.
